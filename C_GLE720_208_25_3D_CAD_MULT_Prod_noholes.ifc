Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:04:55
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:04:55 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{CE82535A-E5AC-4207-ABAC-D78AF56D748B}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:04:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:04:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:04:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE720_208_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: -3000010; Line Weight: 1; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GLE720_208_25_3D_CAD_MULT_Prod_noholes, C_GLE720_208_25_3D_CAD_MULT_Prod_noholes:C_GLE720_208_25_3D_CAD_MULT_Prod_noholes:108182
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00575165 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE720/208/2.5
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GLE720/208/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.181; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Identity Data - Description: Joist hanger; Model: GLE720/208/2.5; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; Copyright: ©Simpson Strong-Tie; ObjectType: GLE720/208/2.5; URL: www.strongtie.eu; Model ID: 0326302774947805223383970503904738321621; OmniClass Number: 23.20.40.11.24.14; Name: GLE720/208/2.5; Provide Feedback: mailto:EUdrawings@strongtie.com; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Product Type: Joist hanger; OmniClass Title: Wood Connectors; Manufacturer: Simpson Strong-Tie
Materials and Finishes - Product Material: Galvanised
