Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:04:54
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:04:54 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{1B08526E-2DB9-46E8-AFDB-1E819AF6D785}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:04:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:04:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:04:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE720_206_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Weight: 1; Line Pattern: -3000010; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GLE720_206_25_3D_CAD_MULT_Prod_noholes, C_GLE720_206_25_3D_CAD_MULT_Prod_noholes:C_GLE720_206_25_3D_CAD_MULT_Prod_noholes:107554
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00575165 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE720/206/2.5
Identity Data - Name: GLE720/206/2.5; OmniClass Number: 23.20.40.11.24.14; Provide Feedback: mailto:EUdrawings@strongtie.com; Manufacturer: Simpson Strong-Tie; URL: www.strongtie.eu; Model ID: 0326302774947805223383970503904738321621; UniClass Title: Joist hangers; UniClass Number: Pr_20_29_31_44; OmniClass Title: Wood Connectors; ObjectType: GLE720/206/2.5; Product Type: Joist hanger; Description: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GLE720/206/2.5; Copyright: ©Simpson Strong-Tie
General - EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE720/206/2.5; Density: 1.181; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
